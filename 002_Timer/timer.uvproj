# Keil uVision project timer.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: timer
  c flags: Optim=1
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x31000000 size 0x1000000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Source Group 1
    ./: S3C2440.s main.c led.c timer.c
